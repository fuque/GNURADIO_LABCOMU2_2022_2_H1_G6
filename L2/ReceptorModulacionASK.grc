options:
  parameters:
    author: G6_H1
    copyright: UIS
    description: Receptor Modulacion ASK en GNURadio
    generate_options: qt_gui
    id: Receptor_ModulacionASK
    output_language: python
    title: Receptor Modulacion ASK
  states: {}

blocks:
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganacia del RX
    start: '0'
    step: '0.5'
    stop: '31'
    value: '0'
  states: {}
- name: fa
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de Amplitud del Filtro
    start: '0'
    step: 1.5625e3
    stop: 781.25e3
    value: 390.625e3
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15625e2
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fa
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc
    dev_args: '""'
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
