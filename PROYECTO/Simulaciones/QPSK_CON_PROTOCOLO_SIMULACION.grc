options:
  parameters:
    generate_options: qt_gui
    id: Simulacion_V1
    output_language: python
    title: QPSK CON HDLC SIMULACION
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '75'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0.00'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j, 0.9998, 0.9998j, -0.9998, -0.9998j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    soft_dec_lut: '"auto"'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts
    sym_rate: 1/float(sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j, 0.4]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.1'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(delay)
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/radiogis/Documents/datos.txt
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '100'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: taps
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Canal
    label1: Receptor
    num_tabs: '2'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'False'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '16'
    mask: '0x21'
    seed: '0x0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pylab
      from gnuradio import gr
      import pmt


      class msg_block(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """This block converts strings from the QT GUI Message Edit Box to uint8 vectors"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern('msg_out'))
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
          
          def handle_msg(self, msg):
              nvec = pmt.to_python(msg)
              self.message_port_pub(pmt.intern('msg_out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(np.array([ord(c) for c in nvec], np.uint8))))
          
          def work(self, input_items, output_items):
              pass
  states: {}
- name: note_0
  id: note
  parameters:
    note: Paquetes
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Señal Modulada
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Canal
  states: {}
- name: note_1
  id: note
  parameters:
    note: Visualizacion
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'transmited@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_2
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@2: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 1,1,1,1
    is_pair: 'False'
    type: string
    value: '"Hola"'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,1,1,1
    name: '"Espectro RX"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,0,1,1
    label1: Rx Bits
    label2: Tx Bits
    name: '"Bits TX vs Bits RX"'
    nconnections: '2'
    size: '128'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'transmited@1: 0,0,1,1'
    label1: Phase I
    label2: Quadrature Q
    name: ''
    size: '500'
    srate: samp_rate
    type: complex
    ymax: '4'
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,1,1,1
    label0: Cons_Sincronizada
    label1: Cons_Equalizada
    label2: Cons_Bloqueada
    num_tabs: '3'
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_hdlc_framer_1
  id: satellites_hdlc_framer
  parameters:
    postamble_bytes: '14'
    preamble_bytes: '100'
  states: {}
- name: satellites_nrzi_decode_0
  id: satellites_nrzi_decode
  parameters: {}
  states: {}
- name: satellites_nrzi_encode_0
  id: satellites_nrzi_encode
  parameters: {}
  states: {}
- name: transmited
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation Post Canal
    label1: Envolvente compleja Post Canal
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mensaje
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Señal_TX
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Salida_Canal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX3
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: Bits_TX
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mensaje
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Señal_TX
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Salida_Canal
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: RX3
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Bits_TX
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: Salida_Canal
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: RX1
  states: {}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: Salida_Canal
  states: {}
- name: virtual_source_4_1
  id: virtual_source
  parameters:
    stream_id: RX2
  states: {}
- name: virtual_source_4_2
  id: virtual_source
  parameters:
    stream_id: RX3
  states: {}

connections:
- [analog_agc3_xx_0, '0', digital_linear_equalizer_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_message_strobe_0, strobe, epy_block_0, msg_in]
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [channels_channel_model_0, '0', virtual_sink_1_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_nrzi_decode_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_2, '0']
- [digital_descrambler_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_descrambler_bb_0, '0', satellites_hdlc_deframer_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0, '0', virtual_sink_4_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', analog_agc3_xx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', virtual_sink_4, '0']
- [digital_scrambler_bb_0, '0', satellites_nrzi_encode_0, '0']
- [epy_block_0, msg_out, satellites_hdlc_framer_1, in]
- [pdu_pdu_to_tagged_stream_0, '0', digital_scrambler_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', virtual_sink_3, '0']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_file_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, blocks_message_strobe_0, set_msg]
- [satellites_hdlc_deframer_0, out, blocks_message_debug_0_0, print]
- [satellites_hdlc_framer_1, out, pdu_pdu_to_tagged_stream_0, pdus]
- [satellites_nrzi_decode_0, '0', digital_descrambler_bb_0, '0']
- [satellites_nrzi_encode_0, '0', blocks_pack_k_bits_bb_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', channels_channel_model_0, '0']
- [virtual_source_1_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_1_1, '0', digital_constellation_soft_decoder_cf_0, '0']
- [virtual_source_2, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_3, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_0_1, '0']
- [virtual_source_4, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_4_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [virtual_source_4_1, '0', qtgui_const_sink_x_0_0_1, '0']
- [virtual_source_4_2, '0', qtgui_const_sink_x_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
